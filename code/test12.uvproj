# Keil uVision project test12.uvproj, settings and files
target Target 1 (MCS-51)
  device: TS80C52X2 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(60000000) MODP2
  output: test12 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 test12.c
